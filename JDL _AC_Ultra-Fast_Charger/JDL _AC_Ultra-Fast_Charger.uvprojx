# Keil uVision project JDL _AC_Ultra-Fast_Charger.uvprojx, settings and files
target JDL _AC_Ultra-Fast_Charger (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: JDL _AC_Ultra-Fast_Charger.elf +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c include: .\Source\APP\AuthM;.\Source\APP\CurrM;.\Source\APP\EnergyM;.\Source\APP\EvseM;.\Source\APP\HmiM;.\Source\APP\RfidAuthM;.\Source\APP\TempM;.\Source\APP\VoltM;.\Source\BSW\ComplexDrivers\CP;.\Source\BSW\ComplexDrivers\Meter;.\Source\BSW\ComplexDrivers\PE;.\Source\BSW\ComplexDrivers\PE;.\Source\BSW\ComplexDrivers\RCD;.\Source\BSW\ComplexDrivers\Relay;.\Source\BSW\ComplexDrivers\RFID;.\Source\BSW\ComplexDrivers\Sensor;.\Source\BSW\ECUAL\Communication\NetDrv;.\Source\BSW\ECUAL\Communication\UartDRv;.\Source\BSW\ECUAL\Crypto\CryptoDrv;.\Source\BSW\ECUAL\IO\LedDrv;.\Source\BSW\ECUAL\IO\PowerDrv;.\Source\BSW\ECUAL\IO\SwitchM;.\Source\BSW\MCAL;.\Source\BSW\MCAL\HAL\STM32F1xx_HAL_Driver\Inc;.\Source\BSW\MCAL\HAL\STM32F1xx_HAL_Driver\Inc\Legacy;.\Source\BSW\MCAL\HAL\CMSIS\Include;.\Source\BSW\MCAL\HAL\CMSIS\Device\ST\STM32F1xx\Include;.\Source\Core\Inc;.\Source\BSW\MCAL\Mcal_Adc;.\Source\BSW\MCAL\Mcal_Common;.\Source\BSW\MCAL\Mcal_Dma;.\Source\BSW\MCAL\Mcal_GPIO;.\Source\BSW\MCAL\Mcal_Gpt;.\Source\BSW\MCAL\Mcal_I2c;.\Source\BSW\MCAL\Mcal_Icu;.\Source\BSW\MCAL\Mcal_InEep;.\Source\BSW\MCAL\Mcal_InFls;.\Source\BSW\MCAL\Mcal_Mcu;.\Source\BSW\MCAL\Mcal_Test;.\Source\BSW\MCAL\Mcal_Uart;.\Source\BSW\MCAL\Mcal_Can;.\Source\BSW\OS\ScheduleTable;.\Source\BSW\OS;.\Source\BSW\Services\SystemServices\Libs\STD_Lib\STD_Rand;.\Source\BSW\Services\SystemServices\Libs\STD_Lib\STD_CycBuff;.\Source\BSW\Services\SystemServices\Libs\STD_Lib\STD_Fifo;.\Source\BSW\Services\SystemServices\Libs\STD_Lib\STD_Filter;.\Source\BSW\Services\SystemServices\Libs;.\Source\BSW\Services\SystemServices\Libs\STD_Lib\STD_Lib;.\Source\BSW\Services\SystemServices\LogService;.\Source\BSW\MCAL\Mcal_Wdg;.\Source\BSW\MCAL\HAL\STM32F1xx_HAL_Driver\Inc;.\Source\BSW\MCAL\Mcal_Spi;.\Source\BSW\Services\CommunicationServices\Ccp;.\Source\BSW\Services\CommunicationServices\Ccp\Ccp;.\Source\APP\EvseM;.\Source\APP\SwitchM;.\Source;.\Source\APP\ErrorHandler;.\Source\BSW\Services\SystemServices\SysM;.\Source\APP\NoAuthenM;.\Source\APP\NetAuth;.\Source\BSW\ComplexDrivers\Battery;.\Source\APP;.\Source\APP\CanM;.\Source\APP\CanM\CanM_EvseM;.\Source\APP\CanM\CanM_MsgM;.\Source\APP\MatlabUtilityToolFiles;.\Source\APP\VoltM;.\Source\BSW\OS\FreeRTOS\include;.\Source\BSW\OS\FreeRTOS\portable\RVDS\ARM_CM3;.\Source\BSW\OS\AppTask;.\Source\BSW\Services\CommunicationServices\RS485_Modbus;.\Source\BSW\Services\SystemServices\Libs\Crc;.\Source\BSW\OS\StreamBuffer;.\Source\APP\FanM;.\Source\BSW\ComplexDrivers\SensorM;.\Source\BSW\Services\CommunicationServices\NetM\atm;.\Source\BSW\Services\CommunicationServices\NetM\atm\Infra;.\Source\BSW\Services\CommunicationServices\NetM\atm\Wrappers;.\Source\BSW\Services\CommunicationServices\NetM\YeeComQ560H;.\Source\BSW\Services\CommunicationServices\NetM\TCP;.\Source\APP\FlashDB;.\Source\BSW\Services\ThirdLibraries\FLashDB\drivers;.\Source\BSW\Services\ThirdLibraries\FLashDB\fal\inc;.\Source\BSW\Services\ThirdLibraries\FLashDB\inc;.\Source\BSW\Services\ThirdLibraries\FLashDB\sfud\inc;.\Source\BSW\Services\ThirdLibraries\FLashDB\Applications;.\Source\BSW\Services\ThirdLibraries\FLashDB\Wrapper;.\Source\APP\FlashDBM;.\Source\BSW\Services\CommunicationServices\NetM\CloudNetM;.\Source\BSW\OS\MessageBuffer;.\Source\APP\CloudM;.\Source\BSW\MCAL\Mcal_Rtc;.\Source\BSW\Services\Tm\STD_RTC;.\Source\APP\CloudM\Cloud_EvM;.\Source\APP\CloudM\Cloud_NetM;.\Source\APP\CloudM\Cloud_ProtocolM;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Gaga;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Gaga\Cloud_Protocol_Callback;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Gaga\Cloud_Protocol_Session;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Gaga\Cloud_Protocol_BillingModelM;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Gaga\Cloud_Protocol_ChargingOrderM;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Gaga\Cloud_Protocol_HeartbeatM;.\Source\BSW\Services\ThirdLibraries\CJson;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Mqtt;.\Source\BSW\Services\CommunicationServices\NetM\CloudNetM\MQTT;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_Sg_Login;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_Ota;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_Sg_PropertySetting;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_Sg_ReportRsponse;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_Sg_ServiceCall;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_Sg_SynchronizeNetTime;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_EventPost;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_EventPost\Cloud_Protocol_EventPostParamInfo;.\Source\APP\CloudM\Cloud_ProtocolM\Cloud_Protocol_Sg\Protocol\Cloud_Protocol_Sg_ServiceCall\Cloud_Protocol_Sg_RemoteCharge
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source/Core
    ./Source/Core/Src/: stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_timebase_tim.c
    ./Source/: main.c dummy.c
  group AuthM
    ./Source/APP/AuthM/: STD_AuthM.c
    ./Source/APP/NoAuthenM/: STD_NoAuthen.c
    ./Source/APP/NetAuth/: STD_NetAuth.c
  group Source/BSW/MCAL/HAL
    ./Source/BSW/MCAL/HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
    ./Source/Core/Src/: stm32f1xx_hal_msp.c
  group Source/BSW/MCAL/Adc
    ./Source/BSW/MCAL/Mcal_Adc/: Mcal_Adc_Cfg.c adc.c
  group Source/BSW/MCAL/Common
    ./Source/BSW/MCAL/Mcal_Common/: Mcal_BigLittle_Endian.c Mcal_BigLittle_Endian.h
  group Source/BSW/MCAL/Dma
    ./Source/BSW/MCAL/Mcal_Dma/: dma.c Mcal_Dma_Cfg.c
  group Source/BSW/MCAL/GPIO
    ./Source/BSW/MCAL/Mcal_GPIO/: Mcal_Gpio_Cfg.h gpio.c Mcal_Gpio_Cfg.c
  group Source/BSW/MCAL/Gpt
    ./Source/BSW/MCAL/Mcal_Gpt/: Mcal_GpTime_Cfg.c Mcal_GpTime_Cfg.h tim.c
  group Source/BSW/MCAL/Mcu
    ./Source/BSW/MCAL/Mcal_Mcu/: Mcal_MCUCore.c Mcal_MCUCore.h Mcal_MCUCore_Cfg.h Mcal_SysTick.c Mcal_SysTick.h
  group Source/BSW/MCAL/Test
    ./Source/BSW/MCAL/Mcal_Test/: Mcal_Test.c Mcal_Test.h
  group Source/BSW/MCAL/Uart
    ./Source/BSW/MCAL/Mcal_Uart/: Mcal_Usart_Cfg.c Mcal_Usart_Cfg.h usart.c
  group Startup
    ./_config/: startup_stm32f107xc.s
  group Source/BSW/MCAL
    ./Source/BSW/MCAL/: Mcal_App.c Mcal_App.h Mcal_App_Cfg.h Mcal_Types.h
  group OS
    ./Source/BSW/OS/: OS.c OS.h STD_Os_Timer.c
    ./Source/BSW/OS/ScheduleTable/: ScheduleTable.c ScheduleTable.h
  group SYS
    ./Source/BSW/Services/SystemServices/SysM/: STD_SysM.c
  group LIB
    ./Source/BSW/Services/SystemServices/Libs/STD_Lib/STD_CycBuff/: STD_CycBuf.c
    ./Source/BSW/Services/SystemServices/Libs/STD_Lib/STD_Fifo/: STD_Fifo.c STD_Fifo_Cfg.c
    ./Source/BSW/Services/SystemServices/Libs/STD_Lib/STD_Filter/: STD_Filter.c
    ./Source/BSW/Services/SystemServices/Libs/STD_Lib/STD_Lib/: STD_Lib.c
    ./Source/BSW/Services/SystemServices/Libs/Crc/: Lib_Crc.c
  group LOG
    ./Source/BSW/Services/SystemServices/LogService/: STD_LogService.c
  group Source/BSW/MCAL/Can
    ./Source/BSW/MCAL/Mcal_Can/: Mcal_Can_Cfg.c can.c
  group Source/BSW/MCAL/IWDG
    ./Source/BSW/MCAL/Mcal_Wdg/: iwdg.c Mcal_iwdg_Cfg.c
  group Source/BSW/MCAL/Spi
    ./Source/BSW/MCAL/Mcal_Spi/: Mcal_Spi_Cfg.c spi.c
  group CCP
    ./Source/BSW/Services/CommunicationServices/Ccp/Ccp/: Ccp.c ccp_DAQ_Tx_Queue.c ex_fun.c
    ./Source/BSW/Services/CommunicationServices/Ccp/: Ccp_CanDrv.c Comm.c
  group Source/APP/EvseM
    ./Source/APP/EvseM/: STD_EvseM.c
  group Source/APP/CanM
    ./Source/APP/CanM/CanM_EvseM/: CanM_EVSEM.c
    ./Source/APP/CanM/: CanM_Rte.c CanM_Rte_Cfg.c
    ./Source/APP/CanM/CanM_MsgM/: CanM_MsgM.c
    ./Source/APP/MatlabUtilityToolFiles/: rt_nonfinite.c rtGetInf.c rtGetNaN.c
  group Source/BSW/CP
    ./Source/BSW/ComplexDrivers/CP/: CpDrvIf.c CpDuty.c CpM.c CpVolt.c
  group Source/APP/ErrHdl
    ./Source/APP/ErrorHandler/: STD_ErrorHandler.c STD_ErrorHandler_Cfg.c
  group Source/BSW/RELAY
    ./Source/BSW/ComplexDrivers/Relay/: STD_MosDrv.c STD_MosDrv_Cfg.c STD_RlyCtrl.c STD_RlyCtrl_Cfg.c STD_RlyM.c
  group Source/BSW/IO/SwitchM
    ./Source/BSW/ECUAL/IO/SwitchM/: SwitchM.c SwitchM_Cfg.c
  group Curr
    ./Source/APP/CurrM/: STD_Curr.c
  group BTR
    ./Source/BSW/ComplexDrivers/Battery/: BtrCtr.c BtrDrvif.c BtrM.c
  group Volt
    ./Source/APP/VoltM/: STD_Volt.c
  group FreeRTOS/src
    ./Source/BSW/OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ./Source/BSW/OS/FreeRTOS/portable/MemMang/: heap_4.c
    ./Source/BSW/OS/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group freeRTOSTask
    ./Source/BSW/OS/AppTask/: AppTask_MainTask.c AppTask_TaskInfo.c AppTask_4gTask.c AppTask_CorePrintTask.c
  group Modbus
    ./Source/BSW/Services/CommunicationServices/RS485_Modbus/: Modbus_Cfg.c Modbus_Hook.c ModbusM.c
  group FreeRTOS/user
    ./Source/BSW/OS/StreamBuffer/: streamBuffer.c
    ./Source/BSW/OS/MessageBuffer/: MessageBuffer.c
  group FanM
    ./Source/APP/FanM/: FanM.c FanM_Drv.c
  group BSW/Sensor
    ./Source/BSW/ComplexDrivers/SensorM/: Sensor.c Sensor_Cfg.c
  group atm
    ./Source/BSW/Services/CommunicationServices/NetM/atm/: at_parser.c
    ./Source/BSW/Services/CommunicationServices/NetM/atm/Infra/: infra_sha256.c infra_md5.c infra_sha1.c
  group at/yeecom
    ./Source/BSW/Services/CommunicationServices/NetM/YeeComQ560H/: YeeComxxx_Callback.c YeeComxxx_At_Cfg.c YeeComxxx_Device.c
    ./Source/BSW/Services/CommunicationServices/NetM/TCP/: Tcp.c
  group FlashDB
    ./Source/BSW/Services/ThirdLibraries/FLashDB/drivers/: drv_spi_flash.c
    ./Source/BSW/Services/ThirdLibraries/FLashDB/fal/src/: fal.c fal_flash.c fal_flash_sfud_port.c fal_partition.c
    ./Source/BSW/Services/ThirdLibraries/FLashDB/fdb/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    ./Source/BSW/Services/ThirdLibraries/FLashDB/sfud/port/: sfud_port.c
    ./Source/BSW/Services/ThirdLibraries/FLashDB/sfud/src/: sfud.c sfud_sfdp.c
    ./Source/BSW/Services/ThirdLibraries/FLashDB/Applications/: fdbM.c
  group fdb_user
    ./Source/BSW/Services/ThirdLibraries/FLashDB/Wrapper/: flashdb_wrapper.c
    ./Source/APP/FlashDBM/: FlashDB_AppM.c
  group CloudNet
    ./Source/BSW/Services/CommunicationServices/NetM/CloudNetM/: CloudNetM.c CloudNet_Protocol_Msg.c
  group CloudM
    ./Source/APP/CloudM/: CloudM.c
    ./Source/APP/CloudM/Cloud_EvM/: Cloud_EV_Charger_Information.c
    ./Source/APP/CloudM/Cloud_NetM/: Cloud_Protocol_Msg.c
    ./Source/APP/CloudM/Cloud_ProtocolM/: Cloud_Protocol.c Cloud_Protocol_Cfg.c
  group RTC
    ./Source/BSW/MCAL/Mcal_Rtc/: Mcal_Rtc_Cfg.c rtc.c
    ./Source/BSW/Services/Tm/STD_RTC/: STD_Rtc.c STD_Rtc_Cfg.c STD_Rtc_Lib.c
  group wrappers
    ./Source/BSW/Services/CommunicationServices/NetM/atm/Wrappers/HAL_OS/freertos/: HAL_OS_Freertos.c
    ./Source/BSW/Services/CommunicationServices/NetM/atm/Wrappers/: wrappers_usart.c
  group Cjson
    ./Source/BSW/Services/ThirdLibraries/CJson/: cJSON.c
  group GagaCloud
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Gaga/Cloud_Protocol_Session/: Cloud_Protocol_Session.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Gaga/Cloud_Protocol_HeartbeatM/: Cloud_Protocol_HeartbeatM.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Gaga/Cloud_Protocol_ChargingOrderM/: Cloud_Protocol_ChargingOrder_Cfg.c Cloud_Protocol_ChargingOrder.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Gaga/Cloud_Protocol_Callback/: Cloud_Protocol_CallbackFunc.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Gaga/Cloud_Protocol_BillingModelM/: Cloud_Protocol_BillingModelM.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Gaga/: Cloud_Protocol_GagaM.c
  group SgCloud
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/: Cloud_Protocol_SgM.c Cloud_Protocol_Sg_Cfg.c
    ./Source/BSW/Services/CommunicationServices/NetM/CloudNetM/MQTT/: CloudNet_Mqtt_PublishM.c CloudNet_MqttM.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Mqtt/: Cloud_Protocol_Mqtt.c Cloud_Protocol_Mqtt_Cfg.c
    ./Source/BSW/Services/CommunicationServices/NetM/CloudNetM/: CloudNet_Cfg.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Protocol/Cloud_Protocol_Sg_Login/: Cloud_Protocol_Sg_Login.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Protocol/Cloud_Protocol_Sg_SynchronizeNetTime/: Cloud_Protocol_Sg_SynchronizeNetTime.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Protocol/Cloud_Protocol_Sg_PropertySetting/: Cloud_Protocol_Sg_PropertySetting.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Protocol/Cloud_Protocol_Sg_ReportRsponse/: Cloud_Protocol_Sg_ReportResponse.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Protocol/Cloud_Protocol_Sg_ServiceCall/: Cloud_Protocol_Sg_ServiceCall.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Protocol/Cloud_Protocol_EventPost/: Cloud_Protocol_EventPost.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Protocol/Cloud_Protocol_EventPost/Cloud_Protocol_EventPostParamInfo/: Cloud_Protocol_EventPost_FwInfo.c Cloud_Protocol_EventPost_VersionInfo.c
    ./Source/APP/CloudM/Cloud_ProtocolM/Cloud_Protocol_Sg/Protocol/Cloud_Protocol_Sg_ServiceCall/Cloud_Protocol_Sg_RemoteCharge/: Cloud_Protocol_Sg_RemoteCharge.c
